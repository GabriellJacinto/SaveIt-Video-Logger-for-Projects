*****MEDIDAS DE ATRASOS DE PROPAGACAO
				*CIN
				.measure tran TP_LH_Cin_0_0 trig v(cin1) val='0.5*supply' rise=1 targ v(sum) val='0.5*supply' rise=1
				.measure tran TP_HL_Cin_0_0 trig v(cin1) val='0.5*supply' fall=1 targ v(sum) val='0.5*supply' fall=1

				.measure tran TP_HL_Cin_0_1 trig v(cin1) val='0.5*supply' rise=2 targ v(sum) val='0.5*supply' fall=2
				.measure tran TP_LH_Cin_0_1 trig v(cin1) val='0.5*supply' fall=2 targ v(sum) val='0.5*supply' rise=3

				.measure tran TP_HL_Cin_1_0 trig v(cin1) val='0.5*supply' rise=3 targ v(sum) val='0.5*supply' fall=4
				.measure tran TP_LH_Cin_1_0 trig v(cin1) val='0.5*supply' fall=3 targ v(sum) val='0.5*supply' rise=5

				.measure tran TP_LH_Cin_1_1 trig v(cin1) val='0.5*supply' rise=4 targ v(sum) val='0.5*supply' rise=6
				.measure tran TP_HL_Cin_1_1 trig v(cin1) val='0.5*supply' fall=4 targ v(sum) val='0.5*supply' fall=6

				*A
				.measure tran TP_LH_0_A_0 trig v(a1) val='0.5*supply' rise=2 targ v(sum) val='0.5*supply' rise=8
				.measure tran TP_HL_0_A_0 trig v(a1) val='0.5*supply' fall=2 targ v(sum) val='0.5*supply' fall=8

				.measure tran TP_HL_0_A_1 trig v(a1) val='0.5*supply' rise=3 targ v(sum) val='0.5*supply' fall=9
				.measure tran TP_LH_0_A_1 trig v(a1) val='0.5*supply' fall=3 targ v(sum) val='0.5*supply' rise=10

				.measure tran TP_HL_1_A_0 trig v(a1) val='0.5*supply' rise=4 targ v(sum) val='0.5*supply' fall=11
				.measure tran TP_LH_1_A_0 trig v(a1) val='0.5*supply' fall=4 targ v(sum) val='0.5*supply' rise=12

				.measure tran TP_LH_1_A_1 trig v(a1) val='0.5*supply' rise=5 targ v(sum) val='0.5*supply' rise=13
				.measure tran TP_HL_1_A_1 trig v(a1) val='0.5*supply' fall=5 targ v(sum) val='0.5*supply' fall=13

				*B
				.measure tran TP_LH_0_0_B trig v(b1) val='0.5*supply' rise=1 targ v(sum) val='0.5*supply' rise=2
				.measure tran TP_HL_0_0_B trig v(b1) val='0.5*supply' fall=1 targ v(sum) val='0.5*supply' fall=3

				.measure tran TP_HL_0_1_B trig v(b1) val='0.5*supply' rise=2 targ v(sum) val='0.5*supply' fall=5
				.measure tran TP_LH_0_1_B trig v(b1) val='0.5*supply' fall=4 targ v(sum) val='0.5*supply' rise=14

				.measure tran TP_HL_1_0_B trig v(b1) val='0.5*supply' rise=4 targ v(sum) val='0.5*supply' fall=12
				.measure tran TP_LH_1_0_B trig v(b1) val='0.5*supply' fall=7 targ v(sum) val='0.5*supply' rise=19

				.measure tran TP_LH_1_1_B trig v(b1) val='0.5*supply' rise=8 targ v(sum) val='0.5*supply' rise=20
				.measure tran TP_HL_1_1_B trig v(b1) val='0.5*supply' fall=8 targ v(sum) val='0.5*supply' fall=20

				*.measure tran maxBA1 param = 'max(tphl_b_a1,tplh_b_a1)'
				*.measure tran maxaux1 param = 'max(maxAB0,maxAB1)'
				*.measure tran maxaux2 param = 'max(maxBA0,maxBA1)'
				*.measure tran maxtp param = 'max(maxaux1,maxaux2)'
				*.measure tran avg_tp param = '(tphl_a_b0 + tplh_a_b0 + tphl_a_b1 + tplh_a_b1 + tphl_b_a0 + tplh_b_a0 + tphl_b_a1 + tplh_b_a1)/8'
*****
