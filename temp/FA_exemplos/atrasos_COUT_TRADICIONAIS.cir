*****MEDIDAS DE ATRASOS DE PROPAGACAO
	.measure tran TP_LH_Cin_0_1 trig v(cin1) val='0.5*supply' rise=1 targ v(cout) val='0.5*supply' rise=1
	.measure tran TP_HL_Cin_0_1 trig v(cin1) val='0.5*supply' fall=1 targ v(cout) val='0.5*supply' fall=1
	.measure tran TP_LH_Cin_1_0 trig v(cin1) val='0.5*supply' rise=2 targ v(cout) val='0.5*supply' rise=2
	.measure tran TP_HL_Cin_1_0 trig v(cin1) val='0.5*supply' fall=2 targ v(cout) val='0.5*supply' fall=2

	.measure tran TP_LH_0_A_1 trig v(a1) val='0.5*supply' rise=2 targ v(cout) val='0.5*supply' rise=3
	.measure tran TP_HL_0_A_1 trig v(a1) val='0.5*supply' fall=2 targ v(cout) val='0.5*supply' fall=3
	.measure tran TP_LH_1_A_0 trig v(a1) val='0.5*supply' rise=3 targ v(cout) val='0.5*supply' rise=4
	.measure tran TP_HL_1_A_0 trig v(a1) val='0.5*supply' fall=3 targ v(cout) val='0.5*supply' fall=4

	.measure tran TP_LH_0_1_B trig v(b1) val='0.5*supply' rise=2 targ v(cout) val='0.5*supply' rise=5
	.measure tran TP_HL_0_1_B trig v(b1) val='0.5*supply' fall=3 targ v(cout) val='0.5*supply' fall=5
	.measure tran TP_LH_1_0_B trig v(b1) val='0.5*supply' rise=3 targ v(cout) val='0.5*supply' rise=6
	.measure tran TP_HL_1_0_B trig v(b1) val='0.5*supply' fall=4 targ v(cout) val='0.5*supply' fall=6
*****
