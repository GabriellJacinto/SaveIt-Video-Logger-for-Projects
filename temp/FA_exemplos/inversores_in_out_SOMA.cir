*****PRIMEIRO INVERSOR
              Mp1inva4 vccin a na vdd          		pmos_rvt w=27.0n l=20n nfin=1
              Mn1inva4 na a vssin ground   			nmos_rvt w=27.0n l=20n nfin=1
              Mp1invb4 vccin b nb vdd          		pmos_rvt w=27.0n l=20n nfin=1
              Mn1invb4 nb b vssin ground   			nmos_rvt w=27.0n l=20n nfin=1
              Mp1invcin4 vccin cin ncin vdd         pmos_rvt w=27.0n l=20n nfin=1
              Mn1invcin4 ncin cin vssin ground   	nmos_rvt w=27.0n l=20n nfin=1
*****

*****SEGUNDO INVERSOR
             Mp2inva4 vcc na a1 vdd          		pmos_rvt w=27.0n l=20n nfin=1
             Mn2inva4 a1 na vss ground   			nmos_rvt w=27.0n l=20n nfin=1
             Mp2invb4 vcc nb b1 vdd          		pmos_rvt w=27.0n l=20n nfin=1
             Mn2invb4 b1 nb vss ground   			nmos_rvt w=27.0n l=20n nfin=1
             Mp2invcin4 vccin ncin cin1 vdd         pmos_rvt w=27.0n l=20n nfin=1
             Mn2invcin4 cin1 ncin vssin ground   	nmos_rvt w=27.0n l=20n nfin=1
******

*****PRIMEIRO FOUT 4 SUM
          	Mp1fout4S vccout sum nsum vdd          	pmos_rvt w=27.0n l=20n nfin=4
         	Mn1fout4S nsum sum vssout ground   		nmos_rvt w=27.0n l=20n nfin=4
******

*****PRIMEIRO FOUT 4 COUT
          	Mp1fout4C vccout cout ncout vdd         pmos_rvt w=27.0n l=20n nfin=4
          	Mn1fout4C ncout cout vssout ground   	nmos_rvt w=27.0n l=20n nfin=4
******
