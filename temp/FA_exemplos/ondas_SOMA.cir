*****ONDAS
	Va a gnd pwl(0n 0 24n 0 24.01n supply 48n supply 48.01n 0 52n 0 52.01n supply 56n supply 56.01n 0 64n 0 64.01n supply 68n supply 68.01n 0 76n 0 76.01n supply 80n supply 80.01n 0 88n 0 88.01n supply 92n supply 92.01n 0 108n 0 108.01n supply 120n supply 120.01n 0 132n 0 132.01n supply 144n supply)
	Vb b gnd pwl(0n 0 12n 0 12.01n supply 22n supply 22.01n 0 36n 0 36.01n supply 46n supply 46.01n 0 60n 0 60.01n supply 72n supply 72.01n 0 84n 0 84.01n supply 94n supply 94.01n 0 100n 0 100.01n supply 104n supply 104.01n 0 112n 0 112.01n supply 116n supply 116.01n 0 124n 0 124.01n supply 128n supply 128.01n 0 136n 0 136.01n supply 140n supply 140.01n 0 144n 0)
	Vcin cin gnd pwl(0n 0 4n 0 4.01n supply 8n supply 8.01n 0 16n 0 16.01n supply 20n supply 20.01n 0 28n 0 28.01n supply 32n supply 32.01n 0 40n 0 40.01n supply 44n supply 44.01n 0 70n 0 70.01n supply 96n supply 96.01n 0 118n 0 118.01n supply 144n supply)
******
